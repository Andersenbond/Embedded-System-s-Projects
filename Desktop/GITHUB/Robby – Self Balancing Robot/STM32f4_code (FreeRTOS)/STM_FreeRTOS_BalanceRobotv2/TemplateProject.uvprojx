# Keil uVision project TemplateProject.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TemplateProject +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX, RVDS_ARMCM4F,HSE_VALUE=8000000
  c include: ..\STM32F4xx_DSP_StdPeriph_Lib_V1.2.0\Libraries\CMSIS\Include;..\STM32F4xx_DSP_StdPeriph_Lib_V1.2.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4xx_DSP_StdPeriph_Lib_V1.2.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\STM_Template_Project;.\FreeRTOS;.\FreeRTOS\Source\include;..\STM_FreeRTOS_Template_Project;..\STM_FreeRTOS_BalanceRobotv2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STM32F4_firmware
    ../STM32F4xx_DSP_StdPeriph_Lib_V1.2.0/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
    ../STM32F4xx_DSP_StdPeriph_Lib_V1.2.0/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../STM32F4xx_DSP_StdPeriph_Lib_V1.2.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_i2c.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_tim.c misc.c stm32f4xx_syscfg.c
  group App
    ../STM32F4xx_DSP_StdPeriph_Lib_V1.2.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c
    ./: main.c ComplementaryFilter.c USART.c Timer.c ExternalInterrupt.c Extra.c KalmanCA.c
  group FreeRTOS
    ./FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/Source/portable/MemMang/: heap_2.c
  group New Group
    ./: tm_stm32f4_i2c.c tm_stm32f4_mpu6050.c tm_stm32f4_gpio.c Kalman.c Auto_Tunning.c
